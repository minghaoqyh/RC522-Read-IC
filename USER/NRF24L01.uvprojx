# Keil uVision project NRF24L01.uvprojx, settings and files
target spi_nrf24l01-TX (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED_IIC
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\CORE;..\USER;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\KEY;..\HARDWARE\NRF24L01_SPI;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\RFID
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RFID/: rc522.c
